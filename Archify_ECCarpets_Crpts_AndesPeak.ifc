Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-14T09:27:15
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_CFIsabel2403, Floor:Archify_ECCarpets_Carpets_AndesPeak_CFIsabel2403:221977
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_CFIsabel2403 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: CF Isabel 2403; ModelReference: Andes Peak; Name: Carpets_AndesPeak_CFIsabel2403_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_CFIsabel2403; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Hudson2425, Floor:Archify_ECCarpets_Carpets_AndesPeak_Hudson2425:222597
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Hudson2425 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Hudson 2425; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Hudson2425_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Hudson2425; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Mendoza2419, Floor:Archify_ECCarpets_Carpets_AndesPeak_Mendoza2419:222613
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Mendoza2419 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Mendoza 2419; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Mendoza2419_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Mendoza2419; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Merida2421, Floor:Archify_ECCarpets_Carpets_AndesPeak_Merida2421:222627
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Merida2421 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Merida 2421; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Merida2421_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Merida2421; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Morado2416, Floor:Archify_ECCarpets_Carpets_AndesPeak_Morado2416:222643
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Morado2416 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Morado 2416; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Morado2416_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Morado2416; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Olca2404, Floor:Archify_ECCarpets_Carpets_AndesPeak_Olca2404:222661
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Olca2404 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Olca 2404; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Olca2404_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Olca2404; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Patagonia2422, Floor:Archify_ECCarpets_Carpets_AndesPeak_Patagonia2422:222677
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Patagonia2422 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Grey; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Patagonia 2422; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Patagonia2422_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Patagonia2422; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Patilla2406, Floor:Archify_ECCarpets_Carpets_AndesPeak_Patilla2406:222691
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Patilla2406 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Brown; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Patilla 2406; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Patilla2406_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Patilla2406; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Rio2451, Floor:Archify_ECCarpets_Carpets_AndesPeak_Rio2451:222707
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Rio2451 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Brown; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Rio 2451; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Rio2451_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Rio2451; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Rubio2458, Floor:Archify_ECCarpets_Carpets_AndesPeak_Rubio2458:222724
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Rubio2458 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Brown; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Rubio 2458; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Rubio2458_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Rubio2458; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Serena2433, Floor:Archify_ECCarpets_Carpets_AndesPeak_Serena2433:222741
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Serena2433 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Brown; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Serena 2433; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Serena2433_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Serena2433; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_AndesPeak_Valera2455, Floor:Archify_ECCarpets_Carpets_AndesPeak_Valera2455:222757
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_AndesPeak_Valera2455 11.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: Brown; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Valera 2455; ModelReference: Andes Peak; Name: Carpets_AndesPeak_Valera2455_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_AndesPeak_Valera2455; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/andes-peak/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
